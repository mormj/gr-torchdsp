options:
  parameters:
    category: Custom
    generate_options: qt_gui
    id: simulator_ofdm
    output_language: python
  states: {}

blocks:
- name: R_max
  id: variable
  parameters:
    value: 3e8/2/samp_rate*fft_len
  states: {}
- name: center_freq
  id: variable
  parameters:
    value: 2.45e9
  states: {}
- name: discarded_carriers
  id: variable
  parameters:
    value: '[]'
  states: {}
- name: fft_len
  id: variable
  parameters:
    value: 2**6
  states: {}
- name: length_tag_key
  id: variable
  parameters:
    value: '"packet_len"'
  states: {}
- name: occupied_carriers
  id: variable
  parameters:
    value: (list(range(-26, -21)) + list(range(-20, -7)) +list( range(-6, 0)) + list(range(1, 7)) + list(range(8, 21)) + list(range(22, 27)),)
  states: {}
- name: occupied_carriers_all
  id: variable
  parameters:
    value: list((range(-26,27),))
  states: {}
- name: packet_len
  id: variable
  parameters:
    value: 2**9
  states: {}
- name: payload_mod
  id: variable
  parameters:
    value: digital.constellation_qpsk()
  states: {}
- name: pilot_carriers
  id: variable
  parameters:
    value: '[(-21, -7, 7, 21,),]'
  states: {}
- name: pilot_symbols
  id: variable
  parameters:
    value: ((1, 1, 1, -1,),)
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '5000000'
  states: {}
- name: sync_word1
  id: variable
  parameters:
    value: '[0., 0., 0., 0., 0., 0., 0., 1.41421356, 0., -1.41421356, 0., 1.41421356, 0., -1.41421356, 0., -1.41421356, 0., -1.41421356, 0., 1.41421356, 0., -1.41421356, 0., 1.41421356, 0., -1.41421356, 0., -1.41421356, 0., -1.41421356, 0., -1.41421356, 0., 1.41421356, 0., -1.41421356, 0., 1.41421356, 0., 1.41421356, 0., 1.41421356, 0., -1.41421356, 0., 1.41421356, 0., 1.41421356, 0., 1.41421356, 0., -1.41421356, 0., 1.41421356, 0., 1.41421356, 0., 1.41421356, 0., 0., 0., 0., 0., 0.]'
  states: {}
- name: sync_word2
  id: variable
  parameters:
    value: '[0, 0, 0, 0, 0, 0, -1, -1, -1, -1, 1, 1, -1, -1, -1, 1, -1, 1, 1, 1, 1, 1, -1, -1, -1, -1, -1, 1, -1, -1, 1, -1, 0, 1, -1, 1, 1, 1, -1, 1, 1, 1, -1, 1, 1, 1, 1, -1, 1, -1, -1, -1, 1, -1, 1, -1, -1, -1, -1, 0, 0, 0, 0, 0] '
  states: {}
- name: transpose_len
  id: variable
  parameters:
    value: int(np.ceil(packet_len*4.0/len(occupied_carriers_all[0])))
  states: {}
- name: v_max
  id: variable
  parameters:
    value: '2000'
  states: {}
- name: value_range
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,0
    label: range
    start: '0.1'
    step: '1'
    stop: R_max
    value: '100'
  states: {}
- name: velocity
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,1
    label: Velocity
    start: '-v_max'
    step: '1'
    stop: v_max
    value: '500'
  states: {}
- name: zeropadding_fac
  id: variable
  parameters:
    value: '2'
  states: {}
- name: analog_noise_source_x_0
  id: analog_noise_source_x
  parameters:
    amp: '0.1'
    noise_type: analog.GR_GAUSSIAN
    seed: '0'
    type: complex
  states: {}
- name: analog_noise_source_x_0_0
  id: analog_noise_source_x
  parameters:
    amp: '1000'
    noise_type: analog.GR_GAUSSIAN
    seed: '0'
    type: complex
  states: {state: disabled}
- name: analog_random_source_x_0
  id: analog_random_source_x
  parameters:
    max: '255'
    min: '0'
    num_samps: '1000'
    repeat: 'True'
    type: byte
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: complex
  states: {}
- name: blocks_add_xx_0_0
  id: blocks_add_xx
  parameters:
    type: complex
  states: {state: disabled}
- name: blocks_complex_to_mag_0
  id: blocks_complex_to_mag
  parameters: {}
  states: {state: disabled}
- name: blocks_complex_to_mag_1
  id: blocks_complex_to_mag
  parameters: {}
  states: {}
- name: blocks_complex_to_mag_squared_0
  id: blocks_complex_to_mag_squared
  parameters:
    vlen: fft_len*zeropadding_fac
  states: {state: disabled}
- name: blocks_complex_to_mag_squared_1_0
  id: blocks_complex_to_mag_squared
  parameters: {}
  states: {state: disabled}
- name: blocks_complex_to_mag_squared_1_0_0
  id: blocks_complex_to_mag_squared
  parameters: {}
  states: {state: disabled}
- name: blocks_nlog10_ff_0
  id: blocks_nlog10_ff
  parameters:
    k: '0'
    n: '1'
    vlen: fft_len*zeropadding_fac
  states: {state: disabled}
- name: blocks_nlog10_ff_1_0
  id: blocks_nlog10_ff
  parameters:
    k: '0'
  states: {state: disabled}
- name: blocks_nlog10_ff_1_0_0
  id: blocks_nlog10_ff
  parameters:
    k: '0'
  states: {state: disabled}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: float
    vlen: fft_len*zeropadding_fac
  states: {state: disabled}
- name: blocks_repack_bits_bb_0
  id: blocks_repack_bits_bb
  parameters:
    endianness: gr.GR_LSB_FIRST
    k: '8'
    l: payload_mod.bits_per_symbol()
    len_tag_key: length_tag_key
  states: {}
- name: blocks_stream_to_tagged_stream_0
  id: blocks_stream_to_tagged_stream
  parameters:
    len_tag_key: length_tag_key
    packet_len: packet_len
    type: byte
  states: {}
- name: blocks_stream_to_vector_0
  id: blocks_stream_to_vector
  parameters:
    num_items: '39'
    type: complex
    vlen: '128'
  states: {}
- name: blocks_stream_to_vector_0_0
  id: blocks_stream_to_vector
  parameters:
    num_items: '128'
    type: complex
    vlen: '39'
  states: {}
- name: blocks_stream_to_vector_0_0_0
  id: blocks_stream_to_vector
  parameters:
    num_items: (fft_len-len(discarded_carriers))*zeropadding_fac
    type: complex
  states: {state: disabled}
- name: blocks_stream_to_vector_0_0_0_0
  id: blocks_stream_to_vector
  parameters:
    num_items: transpose_len
    type: complex
  states: {state: disabled}
- name: blocks_stream_to_vector_1
  id: blocks_stream_to_vector
  parameters:
    num_items: '64'
    type: complex
  states: {state: disabled}
- name: blocks_tag_debug_0
  id: blocks_tag_debug
  parameters:
    type: complex
    vlen: fft_len*2
  states: {state: disabled}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: byte
  states: {}
- name: blocks_vector_source_x_0
  id: blocks_vector_source_x
  parameters:
    repeat: 'True'
    type: complex
    vector: '[x -x*1j for x in list(range(2496))]'
    vlen: '64'
  states: {state: disabled}
- name: blocks_vector_to_stream_0
  id: blocks_vector_to_stream
  parameters:
    num_items: '128'
    type: float
  states: {}
- name: blocks_vector_to_stream_0_0
  id: blocks_vector_to_stream
  parameters:
    num_items: fft_len
    type: complex
  states: {state: disabled}
- name: blocks_vector_to_stream_0_0_0
  id: blocks_vector_to_stream
  parameters:
    num_items: fft_len
    type: complex
  states: {state: disabled}
- name: blocks_vector_to_stream_1
  id: blocks_vector_to_stream
  parameters:
    num_items: '64'
    type: complex
  states: {state: disabled}
- name: blocks_vector_to_stream_1_0
  id: blocks_vector_to_stream
  parameters:
    num_items: '128'
    type: complex
  states: {state: disabled}
- name: blocks_vector_to_stream_2
  id: blocks_vector_to_stream
  parameters:
    num_items: 39*128
    type: complex
  states: {}
- name: blocks_vector_to_stream_3
  id: blocks_vector_to_stream
  parameters:
    num_items: '128'
    type: complex
    vlen: '39'
  states: {}
- name: blocks_vector_to_stream_3_0
  id: blocks_vector_to_stream
  parameters:
    num_items: '39'
    type: complex
    vlen: '128'
  states: {}
- name: digital_chunks_to_symbols_xx_0_0
  id: digital_chunks_to_symbols_xx
  parameters:
    dimension: '1'
    in_type: byte
    minoutbuf: 2*packet_len*4
    out_type: complex
    symbol_table: payload_mod.points()
  states: {}
- name: digital_ofdm_carrier_allocator_cvc_0
  id: digital_ofdm_carrier_allocator_cvc
  parameters:
    fft_len: fft_len
    len_tag_key: length_tag_key
    minoutbuf: 2*transpose_len
    occupied_carriers: occupied_carriers_all
    output_is_shifted: 'True'
    pilot_carriers: ((),)
    pilot_symbols: ((),)
    sync_words: ()
  states: {}
- name: digital_ofdm_cyclic_prefixer_0
  id: digital_ofdm_cyclic_prefixer
  parameters:
    cp_len: fft_len//4
    input_size: fft_len
    minoutbuf: int(2*transpose_len*(fft_len+fft_len/4))
    tagname: length_tag_key
  states: {}
- name: fft_vxx_0
  id: fft_vxx
  parameters:
    fft_size: fft_len
    forward: 'False'
    shift: 'True'
    type: complex
    window: ()
  states: {}
- name: fft_vxx_0_0
  id: fft_vxx
  parameters:
    fft_size: fft_len
    forward: 'True'
    minoutbuf: 2*transpose_len
    shift: 'True'
    type: complex
    window: ()
  states: {state: disabled}
- name: fft_vxx_0_1
  id: fft_vxx
  parameters:
    fft_size: fft_len*zeropadding_fac
    forward: 'True'
    shift: 'False'
    type: complex
    window: window.blackmanharris(fft_len*zeropadding_fac)
  states: {state: disabled}
- name: fft_vxx_0_1_0
  id: fft_vxx
  parameters:
    fft_size: transpose_len
    forward: 'False'
    shift: 'False'
    type: complex
    window: window.blackmanharris(transpose_len)
  states: {state: disabled}
- name: import_0
  id: import
  parameters:
    imports: import numpy as np
  states: {}
- name: import_0_0
  id: import
  parameters:
    imports: from gnuradio import digital
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    size: '102400'
    srate: '1'
    type: complex
  states: {state: disabled}
- name: qtgui_time_sink_x_1
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    size: 128*39
    srate: '1'
    type: float
  states: {state: disabled}
- name: qtgui_time_sink_x_1_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    name: Final
    size: 128*39
    srate: '1'
    type: float
  states: {}
- name: qtgui_time_sink_x_1_0_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    name: Intermediate
    size: 128*39
    srate: '1'
    type: float
  states: {}
- name: radar_estimator_ofdm_0
  id: radar_estimator_ofdm
  parameters:
    axis_x: '[0,R_max]'
    axis_y: '[0,v_max,-v_max,0]'
    len_x: fft_len*zeropadding_fac
    len_y: transpose_len
    merge_consecutive: 'True'
    symbol_x: '''range'''
    symbol_y: '''velocity'''
  states: {state: disabled}
- name: radar_ofdm_cyclic_prefix_remover_cvc_0
  id: radar_ofdm_cyclic_prefix_remover_cvc
  parameters:
    cp_len: fft_len//4
    fft_len: fft_len
    len_key: '"packet_len"'
    minoutbuf: 2*transpose_len
  states: {}
- name: radar_ofdm_divide_vcvc_0
  id: radar_ofdm_divide_vcvc
  parameters:
    discarded_carriers: ()
    len_key: '"packet_len"'
    minoutbuf: 2*transpose_len
    num_sync_words: '0'
    vlen_in: fft_len
    vlen_out: (fft_len-len(discarded_carriers))*zeropadding_fac
  states: {state: disabled}
- name: radar_os_cfar_2d_vc_0
  id: radar_os_cfar_2d_vc
  parameters:
    len_key: '"packet_len"'
    mult_threshold: '30'
    rel_threshold: '0.78'
    samp_compare: '[10,10]'
    samp_protect: '[0,0]'
    vlen: fft_len*zeropadding_fac
  states: {state: disabled}
- name: radar_print_results_0
  id: radar_print_results
  parameters:
    store_msg: 'False'
  states: {state: disabled}
- name: radar_print_results_0_0
  id: radar_print_results
  parameters:
    store_msg: 'False'
  states: {state: disabled}
- name: radar_qtgui_spectrogram_plot_0
  id: radar_qtgui_spectrogram_plot
  parameters:
    autoscale_z: 'True'
    axis_x: '[0,R_max]'
    axis_y: '[0,v_max]'
    axis_z: '[-15,-12]'
    interval: '500'
    label: '''OFDM Radar'''
    len_key: '"packet_len"'
    vlen: fft_len*zeropadding_fac
    xlabel: '''value_range'''
    ylabel: '''Velocity'''
  states: {}
- name: radar_static_target_simulator_cc_0
  id: radar_static_target_simulator_cc
  parameters:
    azimuth: '0'
    center_freq: center_freq
    len_key: '"packet_len"'
    minoutbuf: int(2*transpose_len*(fft_len+fft_len/4))
    position_rx: '0'
    range: value_range
    rcs: 1e25
    rndm_phaseshift: 'True'
    samp_rate: samp_rate
    self_coupling: 'True'
    self_coupling_db: '-10'
    velocity: velocity
  states: {}
- name: radar_transpose_matrix_vcvc_0
  id: radar_transpose_matrix_vcvc
  parameters:
    len_key: '"packet_len"'
    minoutbuf: 2*fft_len*zeropadding_fac
    vlen_in: fft_len*zeropadding_fac
    vlen_out: transpose_len
  states: {state: disabled}
- name: radar_transpose_matrix_vcvc_0_0
  id: radar_transpose_matrix_vcvc
  parameters:
    len_key: '"packet_len"'
    minoutbuf: 2*transpose_len
    vlen_in: transpose_len
    vlen_out: fft_len*zeropadding_fac
  states: {state: disabled}
- name: torchdsp_triton_complex_to_mag_sq_0
  id: torchdsp_triton_complex_to_mag_sq
  parameters:
    device: gpu
    items_per_batch: '1024'
    max_batch_size: '256'
    model_directory: /tmp/rendered_triton_models
    triton_url: localhost:8000
    vlen: '128'
  states: {}
- name: torchdsp_triton_fft_128_fwd_noshift_0
  id: torchdsp_triton_fft_128_fwd_noshift
  parameters:
    device: cpu
    max_batch_size: '256'
    triton_url: localhost:8000
  states: {state: disabled}
- name: torchdsp_triton_fft_128_fwd_noshift_0_0
  id: torchdsp_triton_fft_128_fwd_noshift
  parameters:
    device: gpu
    max_batch_size: '256'
    triton_url: localhost:8000
  states: {state: disabled}
- name: torchdsp_triton_fft_39_rev_0
  id: torchdsp_triton_fft_39_rev
  parameters:
    device: cpu
    max_batch_size: '256'
    triton_url: localhost:8000
  states: {state: disabled}
- name: torchdsp_triton_fft_39_rev_0_0
  id: torchdsp_triton_fft_39_rev
  parameters:
    device: gpu
    max_batch_size: '256'
    triton_url: localhost:8000
  states: {state: disabled}
- name: torchdsp_triton_fft_64_fwd_0
  id: torchdsp_triton_fft_64_fwd
  parameters:
    device: gpu
    max_batch_size: '256'
    triton_url: localhost:8000
  states: {state: disabled}
- name: torchdsp_triton_fft_64_fwd_0_0
  id: torchdsp_triton_fft_64_fwd
  parameters:
    device: cpu
    max_batch_size: '256'
    triton_url: localhost:8000
  states: {state: disabled}
- name: torchdsp_triton_fft_vfvc_0
  id: torchdsp_triton_fft_vfvc
  parameters:
    device: cpu
    fft_size: '64'
    forward: 'True'
    max_batch_size: '256'
    model_directory: /tmp/rendered_triton_models
    shift: 'True'
    triton_url: localhost:8000
  states: {}
- name: torchdsp_triton_fft_vfvc_0_0
  id: torchdsp_triton_fft_vfvc
  parameters:
    device: cpu
    fft_size: '128'
    forward: 'True'
    max_batch_size: '256'
    model_directory: /tmp/rendered_triton_models
    shift: 'False'
    triton_url: localhost:8000
  states: {}
- name: torchdsp_triton_fft_vfvc_0_0_0
  id: torchdsp_triton_fft_vfvc
  parameters:
    device: cpu
    fft_size: '39'
    forward: 'False'
    max_batch_size: '256'
    model_directory: /tmp/rendered_triton_models
    shift: 'True'
    triton_url: localhost:8000
  states: {}
- name: torchdsp_triton_log10_0
  id: torchdsp_triton_log10
  parameters:
    device: gpu
    items_per_batch: '1024'
    max_batch_size: '256'
    model_directory: /tmp/rendered_triton_models
    triton_url: localhost:8000
    vlen: '128'
  states: {}
- name: torchdsp_triton_ofdm_divide_64_128_0
  id: torchdsp_triton_ofdm_divide_64_128
  parameters:
    device: cpu
    max_batch_size: '4096'
    triton_url: localhost:8000
  states: {state: disabled}
- name: torchdsp_triton_ofdm_divide_64_128_0_0
  id: torchdsp_triton_ofdm_divide_64_128
  parameters:
    device: gpu
    max_batch_size: '4096'
    triton_url: localhost:8000
  states: {state: disabled}
- name: torchdsp_triton_ofdm_divide_cc_0
  id: torchdsp_triton_ofdm_divide_cc
  parameters:
    device: cpu
    fft_size_in: '64'
    fft_size_out: '128'
    max_batch_size: '256'
    model_directory: /tmp/rendered_triton_models
    triton_url: localhost:8000
  states: {}
- name: torchdsp_triton_transpose_0
  id: torchdsp_triton_transpose
  parameters:
    device: cpu
    max_batch_size: '2'
    model_directory: /tmp/rendered_triton_models
    ncols: '39'
    nrows: '128'
    triton_url: localhost:8000
  states: {}
- name: torchdsp_triton_transpose_0_0
  id: torchdsp_triton_transpose
  parameters:
    device: cpu
    max_batch_size: '2'
    model_directory: /tmp/rendered_triton_models
    ncols: '128'
    nrows: '39'
    triton_url: localhost:8000
  states: {}
- name: torchdsp_triton_transpose_128_39_0
  id: torchdsp_triton_transpose_128_39
  parameters:
    device: cpu
    max_batch_size: '2'
    triton_url: localhost:8000
  states: {state: disabled}
- name: torchdsp_triton_transpose_128_39_0_0
  id: torchdsp_triton_transpose_128_39
  parameters:
    device: gpu
    max_batch_size: '4096'
    triton_url: localhost:8000
  states: {state: disabled}
- name: torchdsp_triton_transpose_39_128_0
  id: torchdsp_triton_transpose_39_128
  parameters:
    device: cpu
    max_batch_size: '2'
    triton_url: localhost:8000
  states: {state: disabled}
- name: torchdsp_triton_transpose_39_128_0_0
  id: torchdsp_triton_transpose_39_128
  parameters:
    device: gpu
    max_batch_size: '2'
    triton_url: localhost:8000
  states: {state: disabled}

connections:
- [analog_noise_source_x_0, '0', blocks_add_xx_0, '0']
- [analog_noise_source_x_0_0, '0', blocks_add_xx_0_0, '1']
- [analog_random_source_x_0, '0', blocks_throttle_0, '0']
- [blocks_add_xx_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_add_xx_0, '0', radar_ofdm_cyclic_prefix_remover_cvc_0, '0']
- [blocks_add_xx_0_0, '0', blocks_complex_to_mag_squared_1_0, '0']
- [blocks_add_xx_0_0, '0', blocks_complex_to_mag_squared_1_0_0, '0']
- [blocks_add_xx_0_0, '0', blocks_stream_to_vector_1, '0']
- [blocks_complex_to_mag_0, '0', qtgui_time_sink_x_1, '0']
- [blocks_complex_to_mag_1, '0', qtgui_time_sink_x_1_0_0, '0']
- [blocks_complex_to_mag_squared_0, '0', blocks_nlog10_ff_0, '0']
- [blocks_complex_to_mag_squared_1_0, '0', blocks_nlog10_ff_1_0, '0']
- [blocks_complex_to_mag_squared_1_0_0, '0', blocks_nlog10_ff_1_0_0, '0']
- [blocks_nlog10_ff_0, '0', blocks_null_sink_0, '0']
- [blocks_nlog10_ff_0, '0', blocks_vector_to_stream_0, '0']
- [blocks_nlog10_ff_0, '0', radar_qtgui_spectrogram_plot_0, '0']
- [blocks_repack_bits_bb_0, '0', digital_chunks_to_symbols_xx_0_0, '0']
- [blocks_stream_to_tagged_stream_0, '0', blocks_repack_bits_bb_0, '0']
- [blocks_stream_to_vector_0, '0', torchdsp_triton_transpose_0, '0']
- [blocks_stream_to_vector_0, '0', torchdsp_triton_transpose_128_39_0_0, '0']
- [blocks_stream_to_vector_0_0, '0', torchdsp_triton_transpose_0_0, '0']
- [blocks_stream_to_vector_0_0, '0', torchdsp_triton_transpose_39_128_0_0, '0']
- [blocks_stream_to_vector_0_0_0, '0', fft_vxx_0_1, '0']
- [blocks_stream_to_vector_0_0_0, '0', radar_transpose_matrix_vcvc_0, '0']
- [blocks_stream_to_vector_0_0_0_0, '0', fft_vxx_0_1_0, '0']
- [blocks_stream_to_vector_1, '0', torchdsp_triton_ofdm_divide_64_128_0, '0']
- [blocks_stream_to_vector_1, '0', torchdsp_triton_ofdm_divide_64_128_0, '1']
- [blocks_throttle_0, '0', blocks_stream_to_tagged_stream_0, '0']
- [blocks_vector_source_x_0, '0', blocks_vector_to_stream_1, '0']
- [blocks_vector_to_stream_0, '0', qtgui_time_sink_x_1_0, '0']
- [blocks_vector_to_stream_0_0, '0', torchdsp_triton_fft_64_fwd_0_0, '0']
- [blocks_vector_to_stream_0_0_0, '0', blocks_complex_to_mag_squared_1_0_0, '0']
- [blocks_vector_to_stream_0_0_0, '0', torchdsp_triton_ofdm_divide_64_128_0, '0']
- [blocks_vector_to_stream_1, '0', blocks_add_xx_0_0, '0']
- [blocks_vector_to_stream_1_0, '0', blocks_complex_to_mag_0, '0']
- [blocks_vector_to_stream_2, '0', blocks_complex_to_mag_1, '0']
- [blocks_vector_to_stream_3, '0', torchdsp_triton_fft_39_rev_0_0, '0']
- [blocks_vector_to_stream_3, '0', torchdsp_triton_fft_vfvc_0_0_0, '0']
- [blocks_vector_to_stream_3_0, '0', blocks_complex_to_mag_squared_0, '0']
- [blocks_vector_to_stream_3_0, '0', torchdsp_triton_complex_to_mag_sq_0, '0']
- [digital_chunks_to_symbols_xx_0_0, '0', digital_ofdm_carrier_allocator_cvc_0, '0']
- [digital_ofdm_carrier_allocator_cvc_0, '0', blocks_vector_to_stream_0_0_0, '0']
- [digital_ofdm_carrier_allocator_cvc_0, '0', fft_vxx_0, '0']
- [digital_ofdm_carrier_allocator_cvc_0, '0', radar_ofdm_divide_vcvc_0, '0']
- [digital_ofdm_carrier_allocator_cvc_0, '0', torchdsp_triton_ofdm_divide_64_128_0_0, '0']
- [digital_ofdm_carrier_allocator_cvc_0, '0', torchdsp_triton_ofdm_divide_cc_0, '0']
- [digital_ofdm_cyclic_prefixer_0, '0', radar_static_target_simulator_cc_0, '0']
- [fft_vxx_0, '0', digital_ofdm_cyclic_prefixer_0, '0']
- [fft_vxx_0_0, '0', radar_ofdm_divide_vcvc_0, '1']
- [fft_vxx_0_1, '0', radar_transpose_matrix_vcvc_0, '0']
- [fft_vxx_0_1_0, '0', radar_transpose_matrix_vcvc_0_0, '0']
- [fft_vxx_0_1_0, '0', torchdsp_triton_transpose_39_128_0_0, '0']
- [radar_estimator_ofdm_0, Msg out, radar_print_results_0, Msg in]
- [radar_ofdm_cyclic_prefix_remover_cvc_0, '0', blocks_vector_to_stream_0_0, '0']
- [radar_ofdm_cyclic_prefix_remover_cvc_0, '0', fft_vxx_0_0, '0']
- [radar_ofdm_cyclic_prefix_remover_cvc_0, '0', torchdsp_triton_fft_64_fwd_0, '0']
- [radar_ofdm_cyclic_prefix_remover_cvc_0, '0', torchdsp_triton_fft_vfvc_0, '0']
- [radar_ofdm_divide_vcvc_0, '0', fft_vxx_0_1, '0']
- [radar_os_cfar_2d_vc_0, Msg out, radar_estimator_ofdm_0, Msg in]
- [radar_os_cfar_2d_vc_0, Msg out, radar_print_results_0_0, Msg in]
- [radar_static_target_simulator_cc_0, '0', blocks_add_xx_0, '1']
- [radar_transpose_matrix_vcvc_0, '0', blocks_vector_to_stream_2, '0']
- [radar_transpose_matrix_vcvc_0, '0', fft_vxx_0_1_0, '0']
- [radar_transpose_matrix_vcvc_0_0, '0', blocks_complex_to_mag_squared_0, '0']
- [radar_transpose_matrix_vcvc_0_0, '0', blocks_tag_debug_0, '0']
- [radar_transpose_matrix_vcvc_0_0, '0', radar_os_cfar_2d_vc_0, '0']
- [torchdsp_triton_complex_to_mag_sq_0, '0', blocks_nlog10_ff_0, '0']
- [torchdsp_triton_complex_to_mag_sq_0, '0', torchdsp_triton_log10_0, '0']
- [torchdsp_triton_fft_128_fwd_noshift_0, '0', blocks_stream_to_vector_0_0_0, '0']
- [torchdsp_triton_fft_128_fwd_noshift_0, '0', torchdsp_triton_transpose_128_39_0, '0']
- [torchdsp_triton_fft_128_fwd_noshift_0_0, '0', blocks_stream_to_vector_0, '0']
- [torchdsp_triton_fft_128_fwd_noshift_0_0, '0', radar_transpose_matrix_vcvc_0, '0']
- [torchdsp_triton_fft_39_rev_0, '0', torchdsp_triton_transpose_39_128_0, '0']
- [torchdsp_triton_fft_39_rev_0_0, '0', blocks_stream_to_vector_0_0, '0']
- [torchdsp_triton_fft_64_fwd_0, '0', radar_ofdm_divide_vcvc_0, '1']
- [torchdsp_triton_fft_64_fwd_0, '0', torchdsp_triton_ofdm_divide_64_128_0_0, '1']
- [torchdsp_triton_fft_64_fwd_0_0, '0', blocks_complex_to_mag_squared_1_0, '0']
- [torchdsp_triton_fft_64_fwd_0_0, '0', torchdsp_triton_ofdm_divide_64_128_0, '1']
- [torchdsp_triton_fft_vfvc_0, '0', torchdsp_triton_ofdm_divide_cc_0, '1']
- [torchdsp_triton_fft_vfvc_0_0, '0', blocks_stream_to_vector_0, '0']
- [torchdsp_triton_fft_vfvc_0_0_0, '0', blocks_stream_to_vector_0_0, '0']
- [torchdsp_triton_log10_0, '0', blocks_vector_to_stream_0, '0']
- [torchdsp_triton_log10_0, '0', radar_qtgui_spectrogram_plot_0, '0']
- [torchdsp_triton_ofdm_divide_64_128_0, '0', blocks_vector_to_stream_1_0, '0']
- [torchdsp_triton_ofdm_divide_64_128_0, '0', torchdsp_triton_fft_128_fwd_noshift_0, '0']
- [torchdsp_triton_ofdm_divide_64_128_0_0, '0', fft_vxx_0_1, '0']
- [torchdsp_triton_ofdm_divide_64_128_0_0, '0', torchdsp_triton_fft_128_fwd_noshift_0_0, '0']
- [torchdsp_triton_ofdm_divide_cc_0, '0', torchdsp_triton_fft_vfvc_0_0, '0']
- [torchdsp_triton_transpose_0, '0', blocks_vector_to_stream_2, '0']
- [torchdsp_triton_transpose_0, '0', blocks_vector_to_stream_3, '0']
- [torchdsp_triton_transpose_0_0, '0', blocks_vector_to_stream_3_0, '0']
- [torchdsp_triton_transpose_128_39_0, '0', blocks_stream_to_vector_0_0_0_0, '0']
- [torchdsp_triton_transpose_128_39_0, '0', torchdsp_triton_fft_39_rev_0, '0']
- [torchdsp_triton_transpose_128_39_0_0, '0', blocks_vector_to_stream_2, '0']
- [torchdsp_triton_transpose_128_39_0_0, '0', blocks_vector_to_stream_3, '0']
- [torchdsp_triton_transpose_128_39_0_0, '0', fft_vxx_0_1_0, '0']
- [torchdsp_triton_transpose_39_128_0_0, '0', blocks_vector_to_stream_3_0, '0']

metadata:
  file_format: 1
  grc_version: v3.11.0.0git-357-g568fe07b
