options:
  parameters:
    generate_options: qt_gui
    id: vanilla_beamforming
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: bf_angle
  id: variable_qtgui_range
  parameters:
    gui_hint: 1,2,1,1
    start: '-180'
    step: '1'
    stop: '180'
    value: '0.0'
  states: {}
- name: bf_matrix
  id: variable
  parameters:
    value: (tuple([cmath.exp(-2.0*math.pi*m*lam*cmath.sin(theta)*1j) for m in range(4)]),)
  states: {}
- name: lam
  id: variable
  parameters:
    value: '0.5'
  states: {}
- name: nbits
  id: variable
  parameters:
    value: '6'
  states: {}
- name: noise_db
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,2,1,1
    start: '-100.0'
    step: '1'
    stop: '20.0'
    value: '0.0'
  states: {}
- name: noise_level
  id: variable
  parameters:
    value: pow(10,noise_db / 20.0)
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '3200000'
  states: {}
- name: theta
  id: variable
  parameters:
    value: bf_angle * math.pi / 180.0
  states: {}
- name: a1
  id: blocks_add_xx
  parameters:
    type: complex
  states: {}
- name: a2
  id: blocks_add_xx
  parameters:
    type: complex
  states: {}
- name: a3
  id: blocks_add_xx
  parameters:
    type: complex
  states: {}
- name: a4
  id: blocks_add_xx
  parameters:
    type: complex
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '0.5'
    freq: samp_rate / 8
    offset: '0'
    phase: '0'
    samp_rate: 'samp_rate '
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: blocks_multiply_matrix_xx_0
  id: blocks_multiply_matrix_xx
  parameters:
    A: bf_matrix
    tag_propagation_policy: gr.TPP_ALL_TO_ALL
    type: complex
  states: {}
- name: blocks_multiply_matrix_xx_0_0
  id: blocks_multiply_matrix_xx
  parameters:
    A: ((1,1,1,1),)
    tag_propagation_policy: gr.TPP_ALL_TO_ALL
    type: complex
  states: {state: disabled}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: cmath_import
  id: import
  parameters:
    imports: import cmath
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import math
  states: {}
- name: n1
  id: analog_fastnoise_source_x
  parameters:
    amp: noise_level
    noise_type: analog.GR_GAUSSIAN
    samples: '8192'
    seed: '309834890'
    type: complex
  states: {}
- name: n2
  id: analog_fastnoise_source_x
  parameters:
    amp: noise_level
    noise_type: analog.GR_GAUSSIAN
    samples: '8192'
    seed: '-2785836'
    type: complex
  states: {}
- name: n3
  id: analog_fastnoise_source_x
  parameters:
    amp: noise_level
    noise_type: analog.GR_GAUSSIAN
    samples: '8192'
    seed: '14661'
    type: complex
  states: {}
- name: n4
  id: analog_fastnoise_source_x
  parameters:
    amp: noise_level
    noise_type: analog.GR_GAUSSIAN
    samples: '8192'
    seed: '21953407'
    type: complex
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    gui_hint: 2,0,1,1
    name: Single Element
    type: complex
  states: {}
- name: qtgui_freq_sink_x_0_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    gui_hint: 2,2,1,1
    name: After Beamforming
    type: complex
  states: {}
- name: qtgui_freq_sink_x_0_0_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    gui_hint: 2,1,1,1
    name: Summing
    type: complex
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    gui_hint: 0,0,2,2
    nconnections: '4'
    size: '1024'
    srate: samp_rate
    type: complex
  states: {}
- name: torchdsp_phased_array_0
  id: torchdsp_phased_array
  parameters:
    angle_degrees: '125'
    num_elements: '4'
    scale_db: '0'
    sep_lambda: lam
  states: {}
- name: torchdsp_quantize_0
  id: torchdsp_quantize
  parameters:
    nbits: nbits
  states: {}
- name: torchdsp_quantize_0_0
  id: torchdsp_quantize
  parameters:
    nbits: nbits
  states: {}
- name: torchdsp_quantize_0_1
  id: torchdsp_quantize
  parameters:
    nbits: nbits
  states: {}
- name: torchdsp_quantize_0_2
  id: torchdsp_quantize
  parameters:
    nbits: nbits
  states: {}
- name: torchdsp_triton_beamform_cc_0
  id: torchdsp_triton_beamform_cc
  parameters:
    device: cpu
    max_batch_size: '4096'
    triton_url: localhost:8000
  states: {}

connections:
- [a1, '0', torchdsp_quantize_0, '0']
- [a2, '0', torchdsp_quantize_0_0, '0']
- [a3, '0', torchdsp_quantize_0_1, '0']
- [a4, '0', torchdsp_quantize_0_2, '0']
- [analog_sig_source_x_0, '0', blocks_throttle_0, '0']
- [blocks_multiply_matrix_xx_0, '0', qtgui_freq_sink_x_0_0, '0']
- [blocks_multiply_matrix_xx_0_0, '0', qtgui_freq_sink_x_0_0_0, '0']
- [blocks_throttle_0, '0', torchdsp_phased_array_0, '0']
- [n1, '0', a1, '1']
- [n2, '0', a2, '1']
- [n3, '0', a3, '1']
- [n4, '0', a4, '1']
- [torchdsp_phased_array_0, '0', a1, '0']
- [torchdsp_phased_array_0, '1', a2, '0']
- [torchdsp_phased_array_0, '2', a3, '0']
- [torchdsp_phased_array_0, '3', a4, '0']
- [torchdsp_quantize_0, '0', blocks_multiply_matrix_xx_0, '0']
- [torchdsp_quantize_0, '0', blocks_multiply_matrix_xx_0_0, '0']
- [torchdsp_quantize_0, '0', qtgui_freq_sink_x_0, '0']
- [torchdsp_quantize_0, '0', qtgui_time_sink_x_0, '0']
- [torchdsp_quantize_0, '0', torchdsp_triton_beamform_cc_0, '0']
- [torchdsp_quantize_0_0, '0', blocks_multiply_matrix_xx_0, '1']
- [torchdsp_quantize_0_0, '0', blocks_multiply_matrix_xx_0_0, '1']
- [torchdsp_quantize_0_0, '0', qtgui_time_sink_x_0, '1']
- [torchdsp_quantize_0_0, '0', torchdsp_triton_beamform_cc_0, '1']
- [torchdsp_quantize_0_1, '0', blocks_multiply_matrix_xx_0, '2']
- [torchdsp_quantize_0_1, '0', blocks_multiply_matrix_xx_0_0, '2']
- [torchdsp_quantize_0_1, '0', qtgui_time_sink_x_0, '2']
- [torchdsp_quantize_0_1, '0', torchdsp_triton_beamform_cc_0, '2']
- [torchdsp_quantize_0_2, '0', blocks_multiply_matrix_xx_0, '3']
- [torchdsp_quantize_0_2, '0', blocks_multiply_matrix_xx_0_0, '3']
- [torchdsp_quantize_0_2, '0', qtgui_time_sink_x_0, '3']
- [torchdsp_quantize_0_2, '0', torchdsp_triton_beamform_cc_0, '3']
- [torchdsp_triton_beamform_cc_0, '0', qtgui_freq_sink_x_0_0_0, '0']

metadata:
  file_format: 1
  grc_version: v3.11.0.0git-357-g568fe07b
