options:
  parameters:
    generate_options: qt_gui
    id: quantize
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '1000'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '8192'
    type: complex
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    nconnections: '4'
    size: '1024'
    srate: samp_rate
    type: complex
  states: {state: disabled}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: samp_rate
    type: complex
  states: {}
- name: torchdsp_quantize_0
  id: torchdsp_quantize
  parameters:
    nbits: '16'
  states: {state: disabled}
- name: torchdsp_quantize_0_0
  id: torchdsp_quantize
  parameters:
    nbits: '8'
  states: {state: disabled}
- name: torchdsp_quantize_0_1
  id: torchdsp_quantize
  parameters:
    nbits: '6'
  states: {state: disabled}
- name: torchdsp_quantize_0_1_0
  id: torchdsp_quantize
  parameters:
    nbits: '2'
  states: {}

connections:
- [analog_sig_source_x_0, '0', blocks_throttle_0, '0']
- [blocks_throttle_0, '0', torchdsp_quantize_0, '0']
- [blocks_throttle_0, '0', torchdsp_quantize_0_0, '0']
- [blocks_throttle_0, '0', torchdsp_quantize_0_1, '0']
- [blocks_throttle_0, '0', torchdsp_quantize_0_1_0, '0']
- [torchdsp_quantize_0, '0', qtgui_time_sink_x_0, '0']
- [torchdsp_quantize_0_0, '0', qtgui_time_sink_x_0, '1']
- [torchdsp_quantize_0_1, '0', qtgui_time_sink_x_0, '2']
- [torchdsp_quantize_0_1_0, '0', qtgui_freq_sink_x_0, '0']
- [torchdsp_quantize_0_1_0, '0', qtgui_time_sink_x_0, '3']
- [torchdsp_quantize_0_1_0, '0', qtgui_time_sink_x_0_0, '0']

metadata:
  file_format: 1
  grc_version: v3.11.0.0git-348-gab2ee30f
