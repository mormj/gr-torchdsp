options:
  parameters:
    author: josh
    generate_options: qt_gui
    id: asdf
    output_language: python
    run_options: run
    title: Not titled yet
  states: {}

blocks:
- name: fft_size
  id: variable
  parameters:
    value: '2048'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '100'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: complex
    vlen: '512'
  states: {state: disabled}
- name: blocks_null_source_0
  id: blocks_null_source
  parameters:
    type: complex
    vlen: '512'
  states: {state: disabled}
- name: blocks_stream_to_vector_0
  id: blocks_stream_to_vector
  parameters:
    num_items: fft_size
    type: complex
  states: {}
- name: blocks_vector_to_stream_0
  id: blocks_vector_to_stream
  parameters:
    num_items: fft_size
    type: complex
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    size: fft_size
    srate: samp_rate
    type: complex
  states: {}
- name: snippet_0
  id: snippet
  parameters:
    section: main_after_init
  states: {state: disabled}
- name: torchdsp_triton_fft_vfvc_0
  id: torchdsp_triton_fft_vfvc
  parameters:
    device: cpu
    fft_size: fft_size
    forward: 'True'
    max_batch_size: '256'
    model_directory: /tmp/rendered_triton_models
    shift: 'True'
    triton_url: localhost:8000
  states: {}
- name: torchdsp_triton_fft_vfvc_0_0
  id: torchdsp_triton_fft_vfvc
  parameters:
    device: cpu
    fft_size: fft_size
    forward: 'False'
    max_batch_size: '256'
    model_directory: /tmp/rendered_triton_models
    shift: 'True'
    triton_url: localhost:8000
  states: {}

connections:
- [analog_sig_source_x_0, '0', blocks_stream_to_vector_0, '0']
- [blocks_null_source_0, '0', torchdsp_triton_fft_vfvc_0, '0']
- [blocks_stream_to_vector_0, '0', torchdsp_triton_fft_vfvc_0, '0']
- [blocks_vector_to_stream_0, '0', qtgui_time_sink_x_0, '0']
- [torchdsp_triton_fft_vfvc_0, '0', blocks_null_sink_0, '0']
- [torchdsp_triton_fft_vfvc_0, '0', torchdsp_triton_fft_vfvc_0_0, '0']
- [torchdsp_triton_fft_vfvc_0_0, '0', blocks_vector_to_stream_0, '0']

metadata:
  file_format: 1
  grc_version: v3.11.0.0git-357-g568fe07b
