options:
  parameters:
    author: josh
    generate_options: qt_gui
    id: torch_beamform
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '100000'
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: samp_rate / 15
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {state: disabled}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: blocks_vector_source_x_0
  id: blocks_vector_source_x
  parameters:
    repeat: 'True'
    type: complex
    vector: '[complex(2*x,2*x+1) for x in range(50000)]'
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    nconnections: '2'
    type: complex
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    size: samp_rate * 2
    srate: '1'
    type: complex
  states: {}
- name: torchdsp_triton_beamform_cc_0
  id: torchdsp_triton_beamform_cc
  parameters:
    device: cpu
    max_batch_size: '65536'
    triton_url: localhost:8000
  states: {}
- name: torchdsp_triton_copy_0
  id: torchdsp_triton_copy
  parameters:
    device: cpu
    max_batch_size: '16000'
    triton_url: localhost:8000
  states: {state: disabled}

connections:
- [analog_sig_source_x_0, '0', blocks_throttle_0, '0']
- [blocks_throttle_0, '0', qtgui_freq_sink_x_0, '0']
- [blocks_throttle_0, '0', torchdsp_triton_beamform_cc_0, '0']
- [blocks_throttle_0, '0', torchdsp_triton_beamform_cc_0, '1']
- [blocks_throttle_0, '0', torchdsp_triton_beamform_cc_0, '2']
- [blocks_throttle_0, '0', torchdsp_triton_beamform_cc_0, '3']
- [blocks_throttle_0, '0', torchdsp_triton_copy_0, '0']
- [blocks_vector_source_x_0, '0', blocks_throttle_0, '0']
- [torchdsp_triton_beamform_cc_0, '0', qtgui_freq_sink_x_0, '1']
- [torchdsp_triton_beamform_cc_0, '0', qtgui_time_sink_x_0, '0']
- [torchdsp_triton_copy_0, '0', qtgui_freq_sink_x_0, '1']
- [torchdsp_triton_copy_0, '0', qtgui_time_sink_x_0, '0']

metadata:
  file_format: 1
  grc_version: v3.11.0.0git-348-gab2ee30f
